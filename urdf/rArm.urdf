Commit message: temporary good at pose

File: urdf/rArm.urdf (robot description, URDF)
Before this commit: robot rArm, 8 links, 7 joints
Joints:
- joint joint_4: axis 0 1 0 -> 0 -1 0
